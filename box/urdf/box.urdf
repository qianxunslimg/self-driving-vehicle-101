Commit message: car model

File: box/urdf/box.urdf (robot description, URDF)
Before this commit: robot box, 2 links, 1 joints
Links:
- link base_link: geometry collision box size=1 1 1; visual box size=2 2 2
